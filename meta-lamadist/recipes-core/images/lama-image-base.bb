# SPDX-License-Identifier: Apache-2.0

DESCRIPTION = "LamaDist base image"

require lama-image-common.inc
